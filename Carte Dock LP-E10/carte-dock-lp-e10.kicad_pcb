# Repository evolutek/carte-alim

## KiCad design Carte Dock LP-E10/carte-dock-lp-e10.kicad_pcb

Parts:
H1, H2: M2; MountingHole_2.2mm_M2_Pad_Via
J1: BATT; 18K314305
J2, J3: Pad; Pad 4x4mm
J4, J5: Pad; Pad 4x2mm
LB1: LOGO; logo-evo-micro
LB2: LOGO; Logo Aisler Micro

Connections:
-BATT: H1.1, H2.1, J1.1, J1.MP (MountPin), J3.1, J5.1
BATT+: J1.3, J2.1, J4.1

Board: 2 copper layers, 26.5 x 13.3 mm, 13 parts (6 on the bottom side), 2 nets.

Other parts of the board:
kibuzzard-69F63FF2: G***; kibuzzard-69F63FF2
kibuzzard-69F649DA: G***; kibuzzard-69F649DA
kibuzzard-69F649EB: G***; kibuzzard-69F649EB
kibuzzard-69F6400F: G***; kibuzzard-69F6400F

## KiCad design Carte pack 2xLPE-10/Carte pack 2xLPE-10.kicad_pcb

Parts:
C1, C2: 47nF; C_0402_1005Metric
C3, C9: 100nF; C_0402_1005Metric
C4, C5, C6, C7, C8, C10, C11, C12, C14, C15: 10uF; C_0402_1005Metric
C13: 4.7uF; C_0402_1005Metric
C16: 1nF; C_0402_1005Metric
D1: LED
H1, H2, H3: M2; MountingHole_2.2mm_M2_Pad_Via
J1, J4: Conn_01x04_MountingPin; 18K314305
J2, J3, J5: Pad; Pad 4x2mm
L3: LQW21FT1R0M0HL; IND-SMD_L2.0-W1.2-DFP201610TF-R33M; LCSC Part C3224680
Q1: SE2302U; SOT-323-3_L2.1-W1.3-P1.30-LS2.3-BL; LCSC Part C238636
R1: 6.04K; R_0402_1005Metric
R2: 100; R_0402_1005Metric
R3: 1K; R_0402_1005Metric
R4: 5.24K; R_0402_1005Metric
R5: 30.31K; R_0402_1005Metric
R6: 62K; R_0402_1005Metric
R7: 150K; R_0402_1005Metric
U1, U2: BQ25792RQMR; QFN-29_L4.0-W4.0-P0.40-TL-BQ25792RQMR; LCSC Part C2862876
U3, U4: DML3008LFDS-7; DFN2020-8_L2.0-W2.0-P0.50-BL-EP; LCSC Part C17662734
U5: CMFX 103F3435; R0402; LCSC Part C2889040
W7, W8, W9, W10: Solder_Pad; TestPoint_Pad_2.0x2.0mm

Connections:
/ILIM1: R6.2, R7.1, U2.17 (ILIM_HIZ)
/REGOUT1: C13.2, R3.1, R4.1, R7.2, U2.5 (REGN)
/SW1_1: C2.1, L3.1, U2.28 (SW1)
/SW2_1: C1.1, L3.2, U2.26 (SW2)
/VBAT1: C14.2, C15.2, R2.2, U2.22 (BAT), U2.23 (BAT)
/VBATT1: J1.3, U4.1 (VIN), U4.9 (VIN), W7.1; also elsewhere on the board
/VBATT2: J4.3, U3.1 (VIN), U3.9 (VIN), W8.1
/VBUS: U2.2 (VBUS), U2.3 (VBUS), U2.8 (VAC2), U2.9 (VAC1)
/VOUT: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, U2.25 (SYS)
/charger_en: J2.1, Q1.1 (G), U2.13 (~CE), U4.2 (EN)
GND: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, H1.1, H2.1, H3.1, J1.1, J1.MP (MountPin), J3.1, J4.MP (MountPin), Q1.2 (S), R1.2, R5.2, R6.1, U2.10 (ACDRV2), U2.11 (ACDRV1), U2.27 (GND), U3.4 (GND), U4.4 (GND), U5.1
unnamed: D1.2 (A), R3.2
unnamed: D1.1 (K), U2.1 (STAT)
unnamed: J4.1, Q1.3 (D), U4.7 (VOUT), U4.8 (VOUT)
unnamed: J5.1, U3.7 (VOUT), U3.8 (VOUT)
unnamed: R2.1, U2.18 (BATP)
unnamed: C2.2, U2.4 (BTST1)
unnamed: C1.2, U2.19 (BTST2)
unnamed: C9.2, C10.2, C11.2, C12.2, U2.29 (PMID)
unnamed: R1.1, U2.20 (PROG)
unnamed: C16.2, U2.24 (SDRV)
unnamed: R4.2, R5.1, U2.16 (TS), U5.2

Notes on the sheet:
500mA charging
aligner sur grille 1 mm
Power In / Out

Board: 2 copper layers, 44 parts (3 on the bottom side), 20 nets, no tracks yet.

Other parts of the board:
W7#2, W9#2: Solder_Pad; TestPoint_Pad_2.0x2.0mm

Their connections:
/VBATT1: W7#2.1; also elsewhere on the board

## KiCad design Micro carte alim V1/Micro Carte Alim V1.kicad_pcb

Parts:
C1, C2: 1uF; C_0603_1608Metric
TP1, TP2, TP3, TP4: TestPoint; TestPoint_Keystone_5019_Minature
U1: NCP718xSN330; SOT-23-5

Connections:
unnamed: C2.1, TP1.1, U1.1 (IN), U1.3 (EN)
unnamed: C1.2, C2.2, TP2.1, TP4.1, U1.2 (GND)
unnamed: C1.1, TP3.1, U1.5 (OUT)

Board: 2 copper layers, 7 parts (4 on the bottom side), 3 nets, no tracks yet.

## KiCad design Mini carte AU V1/min-carte-au.kicad_pcb

Parts:
C1, C2: 100uF; CP_Elec_6.3x7.7
D1: YELLOW; LED_0805_2012Metric
D3: GREEN; WL-SMTW_3020
J1, J2, J3, J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
PS1: TSR_2-2450
Q1, Q3: Q_NMOS_GSD; SOT-23
Q2: Q_PMOS_GDS; SOT-223-3_TabPin2
R1, R2, R3, R5: 10k; R_0603_1608Metric
R4, R6: 510; R_0603_1608Metric
SW1: Hard AU; SW_Gateron_LowProfile_THT
SW2: Soft AU; SW_PUSH_6mm
SW3: Reset AU; SW_PUSH_6mm
TP1: TestPoint; TestPoint_Pad_D2.0mm
U1: SN74LVC1G32; SOT-23-5
U2: SN74LVC2G74; VSSOP-8_2.3x2mm_P0.5mm

Connections:
+3.3V: J1.1, SW1.1, SW2.1, SW3.1, U1.5 (VCC), U2.2 (D), U2.7 (~PRE), U2.8 (VCC)
+5P: C2.1, J4.1, PS1.3 (+VOUT), Q3.1 (G)
GND: C1.2, C2.2, J1.2, J2.2, J3.2, J4.2, PS1.2 (GND), Q1.2 (S), Q3.2 (S), R1.2, R2.2, R3.2, R4.2, U1.3 (GND), U2.4 (GND)
unnamed: D1.2 (A), Q1.1 (G), U2.3 (~Q)
unnamed: D1.1 (K), R4.1
unnamed: D3.2 (A), R6.2
unnamed: D3.1 (K), Q3.3 (D)
unnamed: Q1.3 (D), Q2.1 (G), R5.2
unnamed: R1.1, SW1.2, U1.1 (A)
unnamed: R3.1, SW2.2, U1.2 (B)
unnamed: TP1.1, U1.4 (S), U2.1 (C)
unnamed: R2.1, SW3.2, U2.6 (~CLR)
VCC: J2.1, Q2.3 (S), R5.1
VPP: C1.1, J3.1, PS1.1 (+VIN), Q2.2 (D), R6.1

Board: 2 copper layers, 50.0 x 30.0 mm, 33 parts (0 on the bottom side), 14 nets.

Other parts of the board:
kibuzzard-67BF20D4: G***; kibuzzard-67BF20D4
kibuzzard-67BF20EF: G***; kibuzzard-67BF20EF
kibuzzard-67BF21E9: G***; kibuzzard-67BF21E9
kibuzzard-67BF210C: G***; kibuzzard-67BF210C
kibuzzard-67BF216A: G***; kibuzzard-67BF216A
kibuzzard-67BF225B: G***; kibuzzard-67BF225B
kibuzzard-67BF2193: G***; kibuzzard-67BF2193
kibuzzard-67C03801: G***; kibuzzard-67C03801
kibuzzard-67FD2C7C: G***; kibuzzard-67FD2C7C

## KiCad design V5/Carte Alim.kicad_pcb

Parts:
H1, H2, H3, H4: M3; WA-SMSI_9774110360
JP1, JP2: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
LB1: CAN ID Label 2
LB2: LOGO; Logo Aisler Min
LB3: LOGO; logo-evo-min

Connections:
/AU/SCL_TEMP: JP2.1 (A); also elsewhere on the board
/AU/SDA_TEMP: JP1.1 (A); also elsewhere on the board
/Input/SCL_INA: JP2.2 (B); also elsewhere on the board
/Input/SDA_INA: JP1.2 (B); also elsewhere on the board
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

Notes on the sheet:
Power Tree sheet
Marking
Mouting holes
Main System
JP1 and JP2 can be cut to disconnect temperature sensors from the I2C.

Parts:
C39: 100nF; C_0603_1608Metric; not fitted
J7: AX12; 22-03-5035
J8, J9, J10, J11: AX12; 22-03-5035; not fitted
J12: Aux VCC; 66200221022
J13: MOTORS; 649002227222-with-larger-pads
J14: Actuators; 649006227222-with-larger-pads
J15, J16: Logical; 66200421022
J17: VPP; 691321100002; not fitted
J18: Aux VPP; PinHeader_1x02_P2.54mm_Vertical; not fitted
J19: 5L Aux; PinHeader_1x02_P2.54mm_Vertical; not fitted
J20: 5L; 691321100002; not fitted
J21, J22: Aux VCC; PinHeader_1x02_P2.54mm_Vertical; not fitted
J23: 5P; 691321100002; not fitted
J24: 5P Aux; PinHeader_1x02_P2.54mm_Vertical; not fitted
J25: Reset Odrive; PinHeader_1x02_P2.54mm_Vertical; not fitted
R44: 10k; R_0603_1608Metric; not fitted
U11: SN74AHC1G09; SC70-5; not fitted

Connections:
+3.3V: C39.1, R44.1, U11.5 (VCC); also elsewhere on the board
+5P: J14.3, J23.1, J24.1; also elsewhere on the board
+5VL: J15.2, J16.2, J19.1, J20.1; also elsewhere on the board
+12L: J15.1, J16.1; also elsewhere on the board
+12P: J7.2, J8.2, J9.2, J10.2, J11.2, J14.2; also elsewhere on the board
/AU/AU_STATUS: U11.2; also elsewhere on the board
/Output Connectors/~RESET_ODRIVE_STM32: R44.2, U11.1; also elsewhere on the board
/Output Connectors/~RST_ODRIVE: J25.1, U11.4
GND: C39.2, J7.3, J8.3, J9.3, J10.3, J11.3, J12.2, J13.2, J14.4, J14.5, J14.6, J15.3, J15.4, J16.3, J16.4, J17.2, J18.2, J19.2, J20.2, J21.2, J22.2, J23.2, J24.2, J25.2, U11.3 (GND); also elsewhere on the board
unnamed: J7.1, J8.1, J9.1, J10.1, J11.1
VCC: J12.1, J21.1, J22.1; also elsewhere on the board
VPP: J13.1, J14.1, J17.1, J18.1; also elsewhere on the board

Notes on the sheet:
AX12
Specific to Evolutek
Output connectors
Specific to Goldorak
Reset Odrive

Parts:
C1, C2, C3, C5, C7, C8, C10, C12: 100nF; C_0603_1608Metric
C4: 560nF; C_0603_1608Metric
C6, C9: 1uF; C_0603_1608Metric
C11: 470uF; CP_Radial_D10.0mm_P5.00mm
D1, D2: D; DO-214AB
D3, D4: 15V; D_SOD-523; not fitted
D5: RED; LED_0805_2012Metric
F1: 20A; FUSE_3557-2
J1: BATT-Evo; 657002140101
J2: EXT-Evo; 657003140101
J3: Power Button; 690367280676
JP3: Jumper_2_Open; PinHeader_1x02_P2.54mm_Horizontal; not fitted
Q1, Q2, Q5: Q_NMOS_GSD; SOT-23
Q3, Q4, Q6, Q7: Si7137DP; PowerPak-SO8_5.15x6.15mm_Pitch1.27mm
R1, R2, R3, R4, R5, R6, R7, R8, R10: 10k; R_0603_1608Metric
R9: 2m; R_2512_6332Metric
U1: LTC2952CUF#PBF; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U2: NCP718xSN330; SOT-23-5
U3: INA219AxDCN; SOT-23-8
U4: MCP9808_MSOP; MSOP-8_3x3mm_P0.65mm

Connections:
+3.3V: C8.1, C9.1, C10.1, R2.1, R4.1, R5.1, R6.1, R7.1, R8.1, U2.5 (OUT), U3.4 (VS), U4.8 (V_{DD}); also elsewhere on the board
+5VL: C6.1, C7.1, U2.1 (IN), U2.3 (EN); also elsewhere on the board
/AU/AU_EXT: J2.3, JP3.2 (B); also elsewhere on the board
/AU/SCL_TEMP: U4.2 (SCL); also elsewhere on the board
/AU/SDA_TEMP: U4.1 (SDA); also elsewhere on the board
/AU/VEXT: D2.1 (K), D4.1 (K), J2.1, JP3.1 (A), Q4.3 (S), U1.13 (V2); also elsewhere on the board
/Input/BLUE_CHANNEL: Q5.1 (G), R3.1; also elsewhere on the board
/Input/BLUE_K: J3.2, Q5.3 (D)
/Input/G1S: R6.2, U1.17 (G1S); also elsewhere on the board
/Input/GREEN_CHANNEL: Q2.1 (G), R2.2; also elsewhere on the board
/Input/GREEN_K: J3.5, Q2.3 (D)
/Input/RED_CHANNEL: Q1.1 (G), R1.1; also elsewhere on the board
/Input/RED_K: J3.3, Q1.3 (D)
/Input/SCL_INA: R7.2, U3.5 (SCL); also elsewhere on the board
/Input/SDA_INA: R8.2, U3.6 (SDA); also elsewhere on the board
/Input/VBATT: F1.1, J1.1
/Input/VBAT_F: D1.1 (K), D3.1 (K), F1.2, Q3.3 (S), U1.15 (V1)
/Input/VCC_SS: C5.1, Q6.3 (S), Q7.3 (S), R9.1, U1.14 (VS), U3.1 (IN+)
/Input/~INT_LTC: R5.2, U1.10 (~INT); also elsewhere on the board
/Input/~KILL: R4.2, U1.20 (~KILL); also elsewhere on the board
/Input/~PB: C1.1, J3.4, U1.4 (~PB)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D1.2 (A), D2.2 (A), J1.2, J2.2, J3.6, Q1.2 (S), Q2.2 (S), Q5.2 (S), R1.2, R3.2, R10.2, U1.1 (VM), U1.2 (PFI), U1.9 (GND), U1.21 (Pad), U2.2 (GND), U3.3 (GND), U3.7 (A0), U3.8 (A1), U4.4 (GND), U4.5 (A2), U4.6 (A1), U4.7 (A0); also elsewhere on the board
unnamed: D3.2 (A), Q3.2 (G), Q6.2 (G), U1.16 (G1)
unnamed: D4.2 (A), Q4.2 (G), Q7.2 (G), U1.12 (G2)
unnamed: D5.1 (K), R10.1
unnamed: Q3.1 (D), Q6.1 (D)
unnamed: Q4.1 (D), Q7.1 (D)
unnamed: U1.18 (M2), U1.19 (M1)
unnamed: C4.1, U1.8 (OFFT)
unnamed: C2.1, C3.1, U1.7 (ONT)
VCC: C11.1, C12.1, D5.2 (A), J3.1, R9.2, U3.2 (IN-); also elsewhere on the board

Notes on the sheet:
Temperature sensor
Power Button
Current/Voltage Measurement
External Input Power with AU 9 - 26V
Input Power Circuit
3.3V Regulation
Power Status Led & Decoupling
Battery Input Power - 9 - 26V
Leds driving cricuit
An external fuse must be added before the input connector
INA219 slave address is 0x40
The sensor needs to be placed below Q3, Q4, Q6 and Q7
Each led is driven with by controlling a NMOS wired on the cathode. By default, the green led is powered.
JP3 can bypass the EXT AU
ONT/OFFT is used to configured the necessary press time to enable/disable the power Configuration: - ONT: 1820 + 26ms - OFFT: 5090 + 26ms
Power button is a RGB tactile switch. The Red, Blue and Green led share a common anode.
MCP9808 slave address is 0x18
Max current: 20A Max Drop voltage: 0.04V Max Power: 0.8W
LDO load: - INA219 (1 mA) - STM32G491 (50 mA) - Led Status (3.3 mA) - SN74AHC1G09 (10 uA) - SN74LVC1G32 (10 uA) - 2 x SN74LVC1G11 (20 uA) - 2 x NMOS gate (200 nA) Total: 55mA

Parts:
C34: 10uF; C_0603_1608Metric
C35, C36, C38: 100nF; C_0603_1608Metric
C37: 10nF; C_0603_1608Metric
D13: GREEN; LED_0805_2012Metric
J5: Comm; 690367280676
J6: STLINK; 62701420621
JP5, JP6: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
R40: 0; R_0603_1608Metric
R41: 10k; R_0603_1608Metric
R42: 120; R_0603_1608Metric
R43: 510; R_0603_1608Metric
U9: STM32G491KEUx; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm-Without thermal pad
U10: MCP2551-I-SN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C34.1, C35.1, C36.1, C37.1, J6.3, JP5.1 (A), U9.1 (VDD), U9.15 (VDDA), U9.17 (VDD); also elsewhere on the board
+5VL: C38.1, U10.3 (VDD); also elsewhere on the board
/AU/AU_EXT_STATUS: U9.10 (PA5); also elsewhere on the board
/AU/AU_ROBOT: U9.11 (PA6); also elsewhere on the board
/AU/AU_STATUS: J5.1; also elsewhere on the board
/AU/AU_STM32: U9.9 (PA4); also elsewhere on the board
/AU/POWER_STATUS: U9.28 (PB5); also elsewhere on the board
/Converters/~RESET_5P: U9.6 (PA1); also elsewhere on the board
/Converters/~RESET_12P: U9.13 (PB0); also elsewhere on the board
/Input/BLUE_CHANNEL: U9.29 (PB6); also elsewhere on the board
/Input/G1S: U9.5 (PA0); also elsewhere on the board
/Input/GREEN_CHANNEL: U9.31 (PB8); also elsewhere on the board
/Input/RED_CHANNEL: U9.30 (PB7); also elsewhere on the board
/Input/SCL_INA: U9.19 (PA9); also elsewhere on the board
/Input/SDA_INA: U9.18 (PA8); also elsewhere on the board
/Input/~INT_LTC: U9.2 (PF0); also elsewhere on the board
/Input/~KILL: U9.3 (PF1); also elsewhere on the board
/Output Connectors/~RESET_ODRIVE_STM32: U9.25 (PA15); also elsewhere on the board
/STM32/CANH: J5.5, JP6.1 (A), U10.7 (CANH)
/STM32/CANL: J5.6, R42.2, U10.6 (CANL)
/STM32/CAN_RX: U9.21 (PA11), U10.4 (RXD)
/STM32/CAN_TX: U9.22 (PA12), U10.1 (TXD)
/STM32/POWER_HOLD: J5.2, JP5.2 (B), R41.1, U9.12 (PA7)
/STM32/STATUS: D13.2 (A), U9.27 (PB4)
/STM32/SWCLK: J6.6, U9.24 (PA14)
/STM32/SWDIO: J6.4, U9.23 (PA13)
/STM32/SWO: J6.8, U9.26 (PB3)
/STM32/VCP_RX: J6.13, U9.8 (PA3)
/STM32/VCP_TX: J6.14, U9.7 (PA2)
/STM32/~INT: J5.3, U9.20 (PA10)
/STM32/~RST: J6.12, U9.4 (PG10)
GND: C34.2, C35.2, C36.2, C37.2, C38.2, J5.4, J6.5, J6.7, J6.11, R40.2, R41.2, R43.2, U9.14 (VSSA), U9.16 (VSS), U9.32 (VSS), U10.2 (VSS); also elsewhere on the board
unnamed: D13.1 (K), R43.1
unnamed: JP6.2 (B), R42.1
unnamed: R40.1, U10.8 (Rs)

Notes on the sheet:
Mapping STM32
STLINK
Status led
STM32
Power Control Connector
CAN
R40 can be used to configure slope control
- TIM4 is used to drive the RGB power button led - FDCAN1 is used to interface the STM32 with the CAN bus - I2C2 is used to communicate with all onboard sensors - UART2 is used for debugging - ~{INT_LTC} / AU_ROBOT / AU_EXT / POWER_HOLD\ are used as external interrupts - PB8 (BOOT0) is mapped as an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
JP5 can be set to bypass Power Hold

Notes on the sheet:
12P: 12V (5A) rail for the actuators
VCC: Batt power for logial purpose
(See Input sheet)
Battery input power
External input power
VPP: Batt power for the actuators / motors
5L: 5V (4/6A) rail for logical purpose (boards, mcus, etc...)
12L: 12V (420mA) rail for logical purpose (sensors, etc...)
5P: 5V (4/6A) rail for the actuators
3.3V: 3.3V (300mA) rail all the logic onboard
