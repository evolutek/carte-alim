# Repository evolutek/carte-alim (continued)

## KiCad design V5/Carte Alim.kicad_pcb (continued)

Parts:
C24, C25, C28, C29, C32, C33: 100nF; C_0603_1608Metric
C26, C27, C31: 470uF; CP_Radial_D10.0mm_P5.00mm
C30: 100uF; CP_Elec_6.3x7.7
D11, D12: D; D_SOD-523
PS1: TEN_60-2412WIN; TRACO_CONV_TEN; PARTREV January 27, 2021
PS2, PS3: THL_20-2411WI; TRACO_CONV_THL; PARTREV Jan 18, 2021
PS4: TDN_5-2412WI; TRACO_CONV_TDN; PARTREV May 18, 2020
Q12, Q13, Q14, Q15: Q_NMOS_GSD; SOT-23
R30, R31: 1k; R_0603_1608Metric
R32, R33: 10k; R_0603_1608Metric
R34, R35, R36, R37, R38, R39: R; R_0603_1608Metric; not fitted

Connections:
+3.3V: R32.1, R33.1; also elsewhere on the board
+5P: C27.1, C29.1, PS2.3 (+VOUT), R36.1; also elsewhere on the board
+5VL: C31.1, C33.1, PS3.3 (+VOUT), R38.1; also elsewhere on the board
+12L: C30.1, C32.1, PS4.7 (+VOUT); also elsewhere on the board
+12P: C26.1, C28.1, PS1.4 (+VOUT), R34.1; also elsewhere on the board
/AU/AU_STATUS: D11.2 (A), D12.2 (A); also elsewhere on the board
/Converters/~RESET_5P: C25.1, Q13.1 (G), R31.2; also elsewhere on the board
/Converters/~RESET_12P: C24.1, Q12.1 (G), R30.2; also elsewhere on the board
GND: C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, PS1.2 (-VIN(GND)), PS1.5 (-VOUT), PS2.2 (-VIN(GND)), PS2.5 (-VOUT), PS3.2 (-VIN(GND)), PS3.5 (-VOUT), PS4.2 (-VIN(GND)), PS4.6 (-VOUT), Q12.2 (S), Q13.2 (S), Q14.2 (S), Q15.2 (S), R35.2, R37.2, R39.2; also elsewhere on the board
unnamed: D11.1 (K), R30.1
unnamed: D12.1 (K), R31.1
unnamed: PS1.3 (ON/OFF), Q14.3 (D)
unnamed: PS1.6 (TRIM), R34.2, R35.1
unnamed: PS2.6 (ON/OFF), Q15.3 (D)
unnamed: PS2.4 (TRIM), R36.2, R37.1
unnamed: PS3.4 (TRIM), R38.2, R39.1
unnamed: Q12.3 (D), Q14.1 (G), R32.2
unnamed: Q13.3 (D), Q15.1 (G), R33.2
VCC: PS1.1 (+VIN(VCC)), PS2.1 (+VIN(VCC)), PS3.1 (+VIN(VCC)), PS4.1 (+VIN(VCC)); also elsewhere on the board

Notes on the sheet:
Documentation
12V actuators power
5V actuators power
5V logical power
12V logical power
ON/OFF control pins are used to enable (high level) or disable (low level) the output of the converters (+ or - 5% max). You can trim the converters output by using: - R34 / R36 / R38 to trim up the voltage - R35 / R37 / R39 to trim down the voltage
R43 and R44 are used to trim PS1 output
Sepcific to Evolutek
R41 and R42 are used to trim PS1 output
R39 and R40 are used to trim PS1 output

Parts:
C13, C14, C15, C16, C17, C18, C19, C22, C23: 100nF; C_0603_1608Metric
C20: 1uf; C_0603_1608Metric
C21: 470uF; CP_Radial_D10.0mm_P5.00mm
D6, D7: 3V; D_SOD-523
D8: YELLOW; LED_0805_2012Metric
D9: 15V; D_SOD-523
D10: D; DO-214AB
J4: AU Robot; 690367280476
JP4: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
Q8, Q9, Q10: Q_NMOS_GSD; SOT-23
Q11: Q_PMOS_GDS; TO-252-2
R11, R13, R14, R19: 33k; R_0603_1608Metric
R12, R16, R17, R18, R20, R21, R22, R24, R25, R26, R27, R28, R29: 10k; R_0603_1608Metric
R15: 5.1k; R_0603_1608Metric
R23: 4.7k; R_0603_1608Metric
U5: SN74LVC1G32; SOT-23-5
U6, U7: SN74LVC1G11; SOT-23-6
U8: MCP9808_MSOP; MSOP-8_3x3mm_P0.65mm

Connections:
+3.3V: C15.1, C16.1, C19.1, C22.1, J4.1, JP4.1 (A), R17.1, U5.5 (VCC), U6.5 (VCC), U7.5 (VCC), U8.7 (A0), U8.8 (V_{DD}); also elsewhere on the board
+5P: R15.1; also elsewhere on the board
+12P: R14.1; also elsewhere on the board
/AU/AU_EXT: R19.1; also elsewhere on the board
/AU/AU_EXT_STATUS: U5.4 (S), U7.1 (A); also elsewhere on the board
/AU/AU_ROBOT: C17.1, J4.2, R24.1, U7.6 (C); also elsewhere on the board
/AU/AU_ROBOT_LED_K: J4.4, R23.1
/AU/AU_STATUS: Q10.1 (G), R27.1, U7.4; also elsewhere on the board
/AU/AU_STM32: C18.1, JP4.2 (B), R26.1, U7.3 (B); also elsewhere on the board
/AU/POWER_STATUS: Q9.1 (G), R22.1, U6.4; also elsewhere on the board
/AU/SCL_TEMP: U8.2 (SCL); also elsewhere on the board
/AU/SDA_TEMP: U8.1 (SDA); also elsewhere on the board
/AU/VEXT: R11.1; also elsewhere on the board
GND: C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C21.2, C22.2, C23.2, D6.2 (A), D7.2 (A), Q8.2 (S), Q9.2 (S), Q10.2 (S), R12.2, R16.2, R18.2, R20.2, R21.2, R22.2, R24.2, R26.2, R27.2, U5.3 (GND), U6.2 (GND), U7.2 (GND), U8.4 (GND), U8.5 (A2), U8.6 (A1); also elsewhere on the board
unnamed: D6.1 (K), R13.2, R21.1, U6.1 (A)
unnamed: C14.1, D7.1 (K), R19.2, R20.1, U5.1 (A)
unnamed: D8.1 (K), R25.1
unnamed: C20.2, D9.2 (A), Q11.1 (G), R28.2, R29.1
unnamed: Q8.3 (D), R17.2, U5.2 (B)
unnamed: C13.1, Q8.1 (G), R11.2, R12.1
unnamed: Q9.3 (D), R23.2, R25.2
unnamed: Q10.3 (D), R29.2
unnamed: R14.2, R18.1, U6.3 (B)
unnamed: R15.2, R16.1, U6.6 (C)
VCC: C20.1, D8.2 (A), D9.1 (K), D10.1 (K), J4.3, Q11.3 (S), R28.1; also elsewhere on the board
VPP: C21.1, C23.1, D10.2 (A), Q11.2 (D), R13.1; also elsewhere on the board

Notes on the sheet:
AU Led driving circuit & power status
Temperature sensor
AU Logical circuit
Documentation
Power enable logic formula: S = AU_ROBOT & AU_STM & (~{VEXT} + AU_EXT)
Robot AU
VPP Power Circuit
EXT AU Logical circuit
MCP9808 slave address is 0x19
AU_EXT: External AU signal 9-26V when the external AU is not pressed
You can short STM32 AU by connecting JP4
The cricuit power the AU led if: - The 5P is present - The 12P is present - The VPP is present
The sensor need to be placed bellow Q11
The AU is a emergency stop with a green led. The AU signal is wired on the NC pin. The Led indicates if the actuators power is enabled.
AU_ROBOT: STM32 AU signal 3.3V when the AU is not pressed
AU_STM32: STM32 AU signal 3.3V when the STM32 enable the power
VEXT: External power sensing signal 9V-26V when the external power is present
The circuit will enable the power for the actuators when: - The AU of the robot is not pressed - The STM32 enable the power - If the external power is connected, the external AU is not pressed. The logcial formula bellow summarize the circuit:

Board: 2 copper layers, 115.0 x 65.0 mm, 207 parts (132 on the bottom side), 81 nets.

Other parts of the board:
kibuzzard-677B4629: G***; kibuzzard-677B4629
kibuzzard-677B4649: G***; kibuzzard-677B4649
kibuzzard-67872BAA: G***; kibuzzard-67872BAA
kibuzzard-67872D20: G***; kibuzzard-67872D20
kibuzzard-67872D71, kibuzzard-67872D71#2: G***; kibuzzard-67872D71
kibuzzard-67872E75: G***; kibuzzard-67872E75
kibuzzard-660203FB: G***; kibuzzard-660203FB
kibuzzard-678726F2: G***; kibuzzard-678726F2
kibuzzard-678729C6, kibuzzard-678729C6#2: G***; kibuzzard-678729C6
kibuzzard-678735CA: G***; kibuzzard-678735CA
kibuzzard-678737AF: G***; kibuzzard-678737AF
kibuzzard-678737BE: G***; kibuzzard-678737BE
kibuzzard-678737CF: G***; kibuzzard-678737CF
kibuzzard-678738AB: G***; kibuzzard-678738AB
kibuzzard-678739A0: G***; kibuzzard-678739A0
kibuzzard-678739C1: G***; kibuzzard-678739C1
kibuzzard-678739E2: G***; kibuzzard-678739E2
kibuzzard-678739EE: G***; kibuzzard-678739EE
kibuzzard-678739F9: G***; kibuzzard-678739F9
kibuzzard-6787393E: G***; kibuzzard-6787393E
kibuzzard-6787394A: G***; kibuzzard-6787394A
kibuzzard-66020582: G***; kibuzzard-66020582
kibuzzard-66020634: G***; kibuzzard-66020634
kibuzzard-66020666: G***; kibuzzard-66020666
kibuzzard-66020679: G***; kibuzzard-66020679
kibuzzard-66020780: G***; kibuzzard-66020780
kibuzzard-67872335: G***; kibuzzard-67872335
kibuzzard-67872371: G***; kibuzzard-67872371
kibuzzard-67872386: G***; kibuzzard-67872386
kibuzzard-67872790: G***; kibuzzard-67872790
kibuzzard-67872810: G***; kibuzzard-67872810
kibuzzard-67873017: G***; kibuzzard-67873017
kibuzzard-67873080: G***; kibuzzard-67873080
kibuzzard-67873255: G***; kibuzzard-67873255
kibuzzard-67873261: G***; kibuzzard-67873261
kibuzzard-67873515, kibuzzard-67873515#2: G***; kibuzzard-67873515
kibuzzard-67873807: G***; kibuzzard-67873807
kibuzzard-67873850: G***; kibuzzard-67873850
kibuzzard-67873964: G***; kibuzzard-67873964

## KiCad design USB C montage panneau/USB C montage panneau.kicad_pcb

Parts:
H1, H2: MountingHole_Pad; WA-SMSI_9774030360
J1: USB_C_Receptacle_PowerOnly_6P; GCT_USB4140-GF-0170-C_REV0.4
J2: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical; not fitted
R1, R2: 5.1k; R_0603_1608Metric; not fitted

Connections:
+5V: J1.A9 (VBUS), J1.B9 (VBUS), J2.1
/CC1: J1.A5 (CC1), J2.3, R1.1
/CC2: J1.B5 (CC2), J2.2, R2.1
GND: H1.1, H2.1, J1.A12 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.4, R1.2, R2.2

Notes on the sheet:
Mouting
Connector
USB C connector

Board: 2 copper layers, 17.0 x 27.0 mm, 6 parts (3 on the bottom side), 4 nets.

## KiCad design Mini carte alim V2/Mini carte alim V2.kicad_pcb

Parts:
C1, C5: 470uF; CP_Radial_D10.0mm_P5.00mm
C2: 2.2uF; C_0603_1608Metric
C3: 1uF; C_0603_1608Metric
C4: 100uF; C_Elec_6.3x7.7
C6, C7, C8, C9, C10: 4.7uF; C_0603_1608Metric
D1, D2, D3: D; DO-214AB
D4: RED; LED_0805_2012Metric
F1: Fuse; 0031.7701.11
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1: BATT; 649002227222
J2: USB_C_Receptacle_PowerOnly_6P; GCT_USB4125-GF-A_REVA2
J3: BAU; 66200421022
J4: Selecteur; 66200621022
J5: VCC; 66200221022
J6, J10: PWR Ext; 66200221022
J7: OUT; 66200421022
J8: 5V; 66200221022
J9: OUT; 66200421122; not fitted
J11: VCC; 66200221122; not fitted
J12: 5V; 66200221122; not fitted
JP1, JP2, JP3, JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
PS1: TDN_5-2412WI; TRACO_CONV_TDN; PARTREV May 18, 2020
PS2: THL_20-2411WI; TRACO_CONV_THL; PARTREV Jan 18, 2021
R1, R2: 5.1K; R_0603_1608Metric
R3: 0; R_0603_1608Metric
R4: 21K; R_0603_1608Metric
R5: 1K; R_0603_1608Metric
U1: IP2721; TSSOP-16_4.4x5mm_P0.65mm
U2: PTN78020W_EUK-7; Texas_EUK_R-PDSS-T7_THT; not fitted
U3: PTN78060W_EUW-7; Texas_EUW_R-PDSS-T7_THT; not fitted

Connections:
+5V: C5.1, C9.1, C10.1, J7.2, J8.1, J9.2, J12.1, PS2.3 (+VOUT), U2.5 (VO_Sense), U2.6 (VO), U3.5 (VO_Sense), U3.6 (VO)
+12V: C4.1, C7.1, J7.1, J9.1, PS1.7 (+VOUT)
/VCCA: D1.1 (K), D2.1 (K), D3.1 (K), F1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D3.2 (A), H1.1, H2.1, H3.1, H4.1, J3.1, J3.3, J4.2, J5.2, J6.2, J7.3, J7.4, J8.2, J9.3, J9.4, J10.2, J11.2, J12.2, PS1.2 (-VIN(GND)), PS1.6 (-VOUT), PS2.2 (-VIN(GND)), PS2.5 (-VOUT), R1.2, R2.2, R4.2, R5.2, U1.5 (GND), U2.1 (GND), U2.7 (GND), U3.1 (GND), U3.7 (GND)
GND1: J1.2, J4.4, JP3.1 (A), JP4.1 (A)
GND2: J2.A12 (GND), J2.B12 (GND), J2.S1 (SHIELD), J4.6, JP1.1 (A), JP2.1 (A)
GNDA: J3.4, J4.5, JP1.2 (B), JP2.2 (B), JP3.2 (B), JP4.2 (B)
unnamed: D4.1 (K), R5.1
unnamed: J2.A5 (CC1), R1.1, U1.13 (CC1)
unnamed: J2.B5 (CC2), R2.1, U1.12 (CC2)
unnamed: C3.1, R3.2, U1.2 (VIN)
unnamed: R4.1, U2.4 (VO_Adj), U3.4 (VO_Adj)
VBUS: D1.2 (A), J2.A9 (VBUS), J2.B9 (VBUS), J4.3
VCC: C1.1, C2.1, C6.1, C8.1, D4.2 (A), F1.1, J3.2, J5.1, J6.1, J10.1, J11.1, PS1.1 (+VIN(VCC)), PS2.1 (+VIN(VCC)), R3.1, U2.2 (VI), U3.2 (VI)
VPP: D2.2 (A), J1.1, J4.1

Notes on the sheet:
Optional connectors
BAU
EXT Power Input
Status Leds
Power Source Selector override
Power Source Selector
Input power circuit
Mouting Holes
USB C Power Input
Power Outputs
Converters
Power Ext
4: GND A 5: GND O 6: GND B
You can solder these connectors if you want the vertical version
R3 is 100 ohms on the original circuit SEL is floating to get 15V from USB battery
1: Led Catode 2: Led Anode 3: NC 4: C
Only one will be solder at the same time.
1: Led A Pwr 2: Leds Signal 3: Led B Pwr
Solder : - JP1 & JP2 to enable USB C power input - JP3 & JP4 to enable EXT power input

Board: 2 copper layers, 85.0 x 50.0 mm, 45 parts (4 on the bottom side), 15 nets.

## KiCad design Mini carte alim V1/Mini carte alim V1.kicad_pcb

Parts:
C1, C3: 470uF; CP_Radial_D10.0mm_P5.00mm
C2: 2.2uF; C_0603_1608Metric
C4, C5, C6, C7, C8: 4.7uF; C_0603_1608Metric
D1: D; DO-214AB
D2, D3: RED; LED_0805_2012Metric
F1: Fuse; 0031.7701.11
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1: BAU; 649004227222
J2: BATT; 649002227222
J3: VCC; 66200221022
J4: OUT; 66200621022
J5: 5V; 66200221022
J6: PWR Ext; B02B-PASK
J7: VCC; 66200221122; not fitted
J8: OUT; 66200621122; not fitted
J9: 5V; 66200221122; not fitted
PS1: THL_20-2411WI; TRACO_CONV_THL; PARTREV Jan 18, 2021
R1: 21K; R_0603_1608Metric
R2, R3: 1K; R_0603_1608Metric
U1: Usb-c_Pdc004_Pd
U2: PTN78020W_EUK-7; Texas_EUK_R-PDSS-T7_THT
U3: PTN78060W_EUW-7; Texas_EUW_R-PDSS-T7_THT

Connections:
+5V: C3.1, C6.1, C8.1, D3.2 (A), J4.2, J5.1, J8.2, J9.1, PS1.3 (+VOUT), U2.5 (VO_Sense), U2.6 (VO), U3.5 (VO_Sense), U3.6 (VO)
+BATT: F1.2, J2.1, U1.1 (VBUS)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.2 (A), H1.1, H2.1, H3.1, H4.1, J1.4, J2.2, J3.2, J4.4, J4.5, J4.6, J5.2, J6.2, J7.2, J8.4, J8.5, J8.6, J9.2, PS1.2 (-VIN(GND)), PS1.5 (-VOUT), R1.2, R2.2, R3.2, U1.2 (GND), U2.1 (GND), U2.7 (GND), U3.1 (GND), U3.7 (GND)
unnamed: D1.1 (K), F1.1, J1.2
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R3.1
unnamed: R1.1, U2.4 (VO_Adj), U3.4 (VO_Adj)
VCC: C1.1, C2.1, C4.1, C5.1, C7.1, D2.2 (A), J1.1, J1.3, J3.1, J4.1, J6.1, J7.1, J8.1, PS1.1 (+VIN(VCC)), U2.2 (VI), U3.2 (VI)

Notes on the sheet:
Optional connectors
BATT Power Input
Status Leds
USB C Power Input
Input power circuit
Mouting Holes
Power Outputs
Converters
Power Ext
Only one will be solder at the same time.

Board: 2 copper layers, 80.0 x 50.0 mm, 32 parts (0 on the bottom side), 8 nets.

## Code that names these connections

File V5/carte-alim-v5.ioc (part):

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Mcu.Name=STM32G491K(C-E)Ux
Mcu.Package=UFQFPN32
Mcu.UserName=STM32G491KEUx
PA0.GPIOParameters=GPIO_PuPd,GPIO_Label
PA0.GPIO_Label=G1S
PA0.GPIO_PuPd=GPIO_PULLUP
PA0.Signal=GPIO_Input
PA1.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PA1.GPIO_Label=RESET_5P
PA1.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PA1.GPIO_PuPd=GPIO_NOPULL
PA1.PinState=GPIO_PIN_SET
PA1.Signal=GPIO_Output
PA10.GPIOParameters=PinState,GPIO_Label
PA10.GPIO_Label=INT
PA10.PinState=GPIO_PIN_SET
PA10.Signal=GPIO_Output
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=CAN_RX
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=CAN_TX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA13.GPIOParameters=GPIO_Label
PA13.GPIO_Label=SWDIO
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.GPIOParameters=GPIO_Label
PA14.GPIO_Label=SWCLK
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=PinState,GPIO_Label
PA15.GPIO_Label=RESET_ODRIVE
PA15.PinState=GPIO_PIN_SET
PA15.Signal=GPIO_Output
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=VCP_TX
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=VCP_RX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.GPIOParameters=PinState,GPIO_Label
PA4.GPIO_Label=AU_STM32
PA4.PinState=GPIO_PIN_SET
PA4.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_PuPd,GPIO_Label
PA5.GPIO_Label=AU_EXT
PA5.GPIO_PuPd=GPIO_PULLDOWN
PA5.Signal=GPXTI5
PA6.GPIOParameters=GPIO_PuPd,GPIO_Label
PA6.GPIO_Label=AU_ROBOT
PA6.GPIO_PuPd=GPIO_PULLDOWN
PA6.Signal=GPXTI6
PA7.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PA7.GPIO_Label=POWER_HOLD
PA7.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING_FALLING
PA7.GPIO_PuPd=GPIO_PULLDOWN
PA7.Signal=GPXTI7
PA8.Mode=I2C
PA8.Signal=I2C2_SDA
PA9.Mode=I2C
PA9.Signal=I2C2_SCL
PB0.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB0.GPIO_Label=RESET_12P
PB0.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB0.GPIO_PuPd=GPIO_NOPULL
PB0.PinState=GPIO_PIN_SET
PB0.Signal=GPIO_Output
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=SWO
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-SWO
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=STATUS
PB4.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_PuPd,GPIO_Label
PB5.GPIO_Label=POWER_STATUS
PB5.GPIO_PuPd=GPIO_PULLDOWN
PB5.Signal=GPIO_Input
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=BLUE_CHANNEL
PB6.Signal=S_TIM4_CH1
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=RED_CHANNEL
PB7.Signal=S_TIM4_CH2
PB8-BOOT0.GPIOParameters=GPIO_Label
PB8-BOOT0.GPIO_Label=GREEN_CHANNEL
PB8-BOOT0.Signal=S_TIM4_CH3
PF0-OSC_IN.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PF0-OSC_IN.GPIO_Label=INT_LTC
PF0-OSC_IN.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PF0-OSC_IN.GPIO_PuPd=GPIO_PULLUP
PF0-OSC_IN.Signal=GPXTI0
PF1-OSC_OUT.GPIOParameters=PinState,GPIO_Label
PF1-OSC_OUT.GPIO_Label=KILL
PF1-OSC_OUT.PinState=GPIO_PIN_SET
PF1-OSC_OUT.Signal=GPIO_Output
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=64000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2020-05-22 Add gitignore
2020-05-22 Add V3
2020-06-12 Add V4
2020-08-10 Update the gitignore
2020-08-10 Add .pro files
2020-08-15 Add Molex AX12 and correct errors
2020-11-14 Add Coffee Machine Logo and update silk screens
2021-01-09 Add Hub Puissance V1.0
2021-01-19 Reduce Hub Puissance V1.0 size
2021-01-24 Add BAU signal comming from external ALIM
2021-01-24 Add Selecteur Entree Puissance V1.0
2021-01-28 Update BAU circuit
2021-01-31 pdf, bom
2021-02-14 Add Hub Puissance V1.1 with correct Mosfets
2021-02-14 First version of theselecteur pcb
2021-02-21 Add PCB V1.0 (previously Selecteur Entree Puissance V1.0)
2021-02-21 Clean Hub Puissance files
2021-02-23 Clean Hub Puissance V1 and patch BAU
2021-02-23 Clean PCB V1.0
2021-03-19 Release V1.2 of Hub Puissance Board
2021-08-06 V1.1 of PCB board
2021-08-13 WIP of V4.1 of the alim board
2021-08-15 Fix schematics labels, generate net list and board layout
2021-08-15 Fix schematics
2021-08-15 WIP PCB
2021-10-23 Add a new board for a battery rack
2021-10-24 Correct XT60 pinout
2021-10-24 Corrected schematics
2021-10-24 WIP v2 version of PCB board
2021-10-24 First version of the PCB
2021-10-24 After Alf@ review
2021-10-24 Clean files
2021-10-24 Move board into Vertical version
2021-10-24 Fix missing 3D model for JST XH 5
2021-10-25 Add a horizontal version of the carte rack batterie
2021-11-28 Fix Carte Rack Batterie Vertical (V1.1)
2021-12-07 Fix PCB V2
2021-12-07 wip carte alim v4
2021-12-07 First shot at full routing of the board. To be improved further.
2021-12-09 Release Carte Alim V4
2022-03-16 Release V4.1
    Fix
2022-04-29 Fix with V4.2
2022-04-30 Fix silkscreen
2022-11-11 V1.0 of the Carte Boitier BAU
2022-12-02 Release V1.1 of carte boitier BAU
2023-04-28 WIP Mini carte alim V1
2023-04-28 V1.0 of Mini carte alim
2023-04-29 Move R1 to top
2023-04-30 More compact version
2023-04-30 Fix some planes
2023-07-25 V1.1 with a diode to prevent polarity inversion
2023-07-29 Add vertical output connectors and minor improvments
2023-10-14 Wip Mini Carte Alim V2, need to correct some errors
2023-10-15 Mini Carte Alim V2.0
2023-11-05 Fix Mini carte alim V2
2023-12-16 Mini carte alim V2.1
2023-12-19 Update connecting indications
2024-01-22 USB C panel mount V1
2024-01-22 Clean board and generate ouput files
2024-01-22 Clean file
2024-02-17 WIP Carte alim V5
2024-02-25 WIP Schematics
2024-03-10 Clean schematics and start PCB
2024-03-10 Rename Converters sheet
2024-03-10 WIP placement (it's short)
2024-03-12 Mapping STM32 and PCB ongoing
2024-03-12 Mapping Done, routing simple complex
2024-03-24 PCB done, needs to be checked
2024-03-26 Add production files for Evolutek
2024-03-26 Add missing files
2024-03-26 Add Goldorak variante of production files
2024-03-30 Clean
2024-04-08 Update GPIO Config
2024-12-21 WIP V5.1
2025-01-15 Release V5.1 variante Evolutek
2025-02-20 Move PNG and IOC
2025-02-20 Add first version of the firmware
2025-02-26 Release Mini carte AU V1.0
2025-02-27 Minor fixes on V1.0
2025-03-02 Add carte dock lp-e10
2025-03-11 Carte Dock LP-E10 update
    minimise
2025-03-21 Minor fixes on V5.1
2025-03-21 Update V5.1 zip name
2025-03-21 Fix board outline and add fab files
2025-03-26 Update R7/R8 value
2025-03-26 Remove backups
2025-04-07 Add minimal firmware for V5.1
2025-04-07 Remove debug folder
2025-04-14 Release V1.1
2025-05-10 done
2025-05-14 Release Micro Carte Alim V1.0
2026-03-08 Carte pack 2xLPE-10 WIP schematic
    TODO :
    - Check the remaining value of the charger (checked max charge, PROG and NTC)
    - Choose LED for charger
    - Wait for load switch validation
2026-05-02 Cleanup
2026-05-02 V1.1
